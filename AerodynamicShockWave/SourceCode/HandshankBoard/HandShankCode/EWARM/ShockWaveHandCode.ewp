# IAR project ShockWaveHandCode.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K6 STM8S105K6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\FWLib\inc; ..\User\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: ShockWaveHandCode.bin
  ILINK.IlinkOutputFile: ShockWaveHandCode.out
  ILINK.IlinkIcfFile: D:\LXY\MA-G2-1\SourceCode\Certification\HandshankBoard\ShockWaveHandCode_Certification\EWARM\lnkstm8s105k6.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group FWLib
    ../FWLib/src/: stm8s_adc1.c stm8s_clk.c stm8s_flash.c stm8s_gpio.c stm8s_itc.c stm8s_iwdg.c stm8s_tim2.c stm8s_tim4.c stm8s_uart2.c stm8s_wwdg.c
    ../User/inc/: stm8s_conf.h
  group User
    ../User/src/: adc.c character.c crc16.c fifo.c key.c main.c oled_parallel.c protocol.c sys.c temperature.c timer.c uart.c uart_printf.c upg.c
