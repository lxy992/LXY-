# IAR project Aerodynamic.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F105RB ST STM32F105RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_CL; USE_STDPERIPH_DRIVER; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\iar; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\User\inc; ..\FreeRTOS\include; ..\FreeRTOS\portable\IAR\ARM_CM3; ..\FreeRTOS\portable\MemMang; ..\Libraries\CMSIS\CM3\CoreSupport
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\FreeRTOS\include
  OBJCOPY.OOCOutputFile: H4.bin
  ILINK.IlinkOutputFile: Ultrasonic_LineCarve.out
  ILINK.IlinkIcfFile: Aerodynamic.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: system_stm32f10x.c
  group EWARM
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/IAR/ARM_CM3/: port.c portasm.s
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../User/src/: bsp_adc.c bsp_beep.c bsp_decode.c bsp_dwin.c bsp_function.c bsp_key.c bsp_left_hand.c bsp_pressure.c bsp_right_hand.c bsp_serial.c bsp_stmflash.c bsp_sys.c bsp_takt.c bsp_uid_encryption.c main.c stm32f10x_it.c
